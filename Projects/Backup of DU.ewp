# IAR project Backup of DU.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\App; ..\task; ..\MALLOC; ..\FATFS\exfuns; ..\FATFS\src; ..\FATFS\src\option; ..\Bsp; ..\user; ..\ZTM_LIB; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Libraries\STM32F10x_StdPeriph_Driver\src; ..\uCOS-II\Ports; ..\uCOS-II\Source; ..\uCOS-II\Config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DU.hex
  ILINK.IlinkOutputFile: DU.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    ../App/: app.c app_read_ect.c display.c esc_record_data.c key_process.c lcd_text.c main_display.c sub_comm.c time_display.c
  group BSP
    ../Bsp/: BSP.c bsp_key.c bsp_rtc_1302.c bsp_usart.c spi.c spi_flash.c
  group FWLib/CMSIS/Startup
    ./: startup_stm32f10x_hd.s
  group FWLib/scr
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group MENU
    ../App/: menu.c menu_error_record.c
    ../User/: menu_base_para.c menu_comm_config.c menu_error_config.c menu_esc_backup.c menu_esc_sn.c menu_io_config.c menu_language.c menu_process.c menu_statistic.c
  group Task
    ../task/: task_help.c task_lcm_init.c
  group ucos/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group ucos/Source/Port
    ../uCOS-II/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
  group USER
    ../User/: crc16.c
    ./: includes.h main.c stm32f10x_conf.h stm32f10x_it.c system_stm32f10x.c
  group ZTM
    ../ZTM_LIB/: ZTM.h ZTM_API.c ZTM_DRV.c
